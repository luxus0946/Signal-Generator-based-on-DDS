# Keil uVision project DDS.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: DDS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hardware;..\DDS
  group user
    ./: main.c
  group Hardware
    ./hardware/: AD9833.c AD9833.h key.c key.h oled.c oled.h oledfont.h delay.h delay.c flash.c flash.h
    ./: STC8H.h
  group docs
    ./Docs/: 说明.txt
  group start
    ./: STARTUP.A51
